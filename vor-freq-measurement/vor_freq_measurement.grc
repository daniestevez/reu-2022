options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: vor_freq_measurement
    output_language: python
    title: VOR frequency measurement
  states: {}

blocks:
- name: center_frequency
  id: variable
  parameters:
    value: 117e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '100'
  states: {}
- name: decimation2
  id: variable
  parameters:
    value: '16'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 117.3e6
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Gain (digital)
    type: real
    value: '50'
  states: {}
- name: lowpass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 0.45 * samp_rate / decimation
    gain: '1.0'
    samp_rate: samp_rate
    width: 0.1 * samp_rate / decimation
    win: window.WIN_HAMMING
  states: {}
- name: lowpass_taps2
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 0.45 * samp_rate/(decimation*decimation2)
    gain: '1.0'
    samp_rate: samp_rate / decimation
    width: 0.1 * samp_rate/(decimation*decimation2)
    win: window.WIN_HAMMING
  states: {}
- name: pll_bw_hz
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rf_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: RF gain
    type: real
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: tune
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2,1,1
    label: Fine tuning (Hz)
    type: real
    value: '90'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: np.pi
    min_freq: '- np.pi'
    w: 2 * np.pi * pll_bw_hz / (samp_rate / (decimation * decimation2))
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.25'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: phase_measurement_10sps.f32
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '200'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decimation2
    taps: lowpass_taps2
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: frequency - center_frequency + tune
    decim: decimation
    samp_rate: samp_rate
    taps: lowpass_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '9960'
    decim: decimation2
    samp_rate: samp_rate / decimation
    taps: lowpass_taps2
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 1,0,1,3
    name: Full spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '4096'
    gui_hint: 2,0,1,3
    name: VOR spectrum
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,3
    label1: PLL input (I)
    label2: PLL input (Q)
    label3: PLL output (I)
    label4: PLL output (Q)
    name: PLL
    nconnections: '2'
    size: '2000'
    srate: samp_rate/(decimation * decimation2)
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: AM
    label2: FM
    name: VOR signals
    nconnections: '2'
    size: '2000'
    srate: samp_rate/(decimation * decimation2)
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: Carrier phase
    size: '2000'
    srate: samp_rate/(decimation * decimation2)
    type: float
    ylabel: Phase
    ymax: np.pi
    ymin: '-np.pi'
    yunit: rad
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_frequency
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: carrier
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: vor
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: carrier
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: vor
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_complex_to_magphase_0, '0']
- [analog_pll_refout_cc_0, '0', qtgui_time_sink_x_0, '1']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_1, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_keep_one_in_n_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_1, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', analog_quadrature_demod_cf_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', analog_pll_refout_cc_0, '0']
- [virtual_source_1, '0', blocks_complex_to_mag_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
