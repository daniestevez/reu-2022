options:
  parameters:
    author: daniel
    generate_options: qt_gui
    id: interferometry_demo
    output_language: python
    title: Interferometry Demo
  states: {}

blocks:
- name: ant2_delay
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,0,1,1
    label: Antenna 2 delay
    type: int
    value: '0'
  states: {}
- name: ant2_phase
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,1,1,1
    label: Antenna 2 phase (rad)
    type: real
    value: '0'
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '256'
  states: {}
- name: nfft_spec
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40.96e6
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft_spec
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft_spec
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: complex
    vlen: nfft
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft_spec
  states: {}
- name: blocks_repeat_0_0_0_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft_spec
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(nfft)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,1,1,1
    legend: 'False'
    name: Lag domain IQ
    size: nfft
    style1: '1'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: 1,0,1,1
    name: '"Lag domain power"'
    vlen: nfft
    x_axis_label: '"Delay (samples)"'
    x_start: '0'
    x_step: '1.0'
    x_units: '"samples"'
    y_axis_label: '"Power"'
    ymax: '1'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 0,0,1,1
    name: '"Received spectrum"'
    nconnections: '2'
    vlen: nfft_spec
    x_axis_label: '"FFT bin"'
    x_start: '0'
    x_step: '1.0'
    x_units: '"samples"'
    y_axis_label: '"Power"'
    ymax: '1'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 1,1,1,1
    name: '"Frequency domain phase"'
    vlen: nfft
    x_axis_label: '"Frequency (Hz)"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/nfft
    x_units: '"Hz"'
    y_axis_label: '"Phase (rad)"'
    y_units: '"rad"'
    ymax: np.pi
    ymin: '-np.pi'
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: gnuradio1
    callback: set_ant2_delay
    port: '8080'
    variable: ant2_delay
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: gnuradio1
    callback: set_ant2_phase
    port: '8080'
    variable: ant2_phase
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://gnuradio1:5557
    timeout: '100'
    type: float
    vlen: nfft_spec
  states: {}
- name: zeromq_sub_source_0_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://gnuradio1:5555
    timeout: '100'
    type: complex
    vlen: nfft
  states: {}
- name: zeromq_sub_source_0_0_1
  id: zeromq_sub_source
  parameters:
    address: tcp://gnuradio1:5556
    timeout: '100'
    type: float
    vlen: nfft_spec
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0_0, '1']
- [blocks_repeat_0_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_repeat_0_0, '0', fft_vxx_0_1, '0']
- [blocks_repeat_0_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_repeat_0_0_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_1, '0', blocks_vector_to_stream_0, '0']
- [zeromq_sub_source_0_0, '0', blocks_repeat_0_0_0_0, '0']
- [zeromq_sub_source_0_0_0, '0', blocks_repeat_0_0, '0']
- [zeromq_sub_source_0_0_1, '0', blocks_repeat_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
