options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: interferometry_ata_server
    output_language: python
    run_options: run
    title: Interferometry  ATA server
  states: {}

blocks:
- name: ant2_delay
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ant2_phase
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 512e6
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '256'
  states: {}
- name: nfft_spec
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: t_int
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft_spec
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft_spec
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: ant2_delay
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(t_int*samp_rate/nfft)
    type: complex
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_1
  id: blocks_integrate_xx
  parameters:
    decim: int(t_int*samp_rate/nfft_spec)
    type: float
    vlen: nfft_spec
  states: {}
- name: blocks_integrate_xx_0_1_0
  id: blocks_integrate_xx
  parameters:
    decim: int(t_int*samp_rate/nfft_spec)
    type: float
    vlen: nfft_spec
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: nfft
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1j * ant2_phase)
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft_spec
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft_spec
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(nfft)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(nfft)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    fft_size: nfft_spec
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackman(nfft_spec)
  states: {}
- name: fft_vxx_0_2_0
  id: fft_vxx
  parameters:
    fft_size: nfft_spec
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackman(nfft_spec)
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '45'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 40.96e6
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.uhd_usrp_source.set_time_next_pps(uhd.time_spec(int(time.time())+1))
      self.uhd_usrp_source.set_lo_export_enabled(True, "lo1", 0)
      self.uhd_usrp_source.set_rx_lo_dist(True, "LO_OUT_0")
      self.uhd_usrp_source.set_rx_lo_dist(True, "LO_OUT_1")
      self.uhd_usrp_source.set_lo_source("external", "lo1", 0)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 1)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 2)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 3)
      time.sleep(1)
    section: main_after_init
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    ant2: RX2
    ant3: RX2
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    clock_source0: external
    clock_source1: external
    dev_addr: '"addr0=10.11.1.20,addr1=10.11.1.22"'
    dev_args: '""'
    gain0: gaindB
    gain1: gaindB
    gain2: gaindB
    gain3: gaindB
    nchan: '4'
    num_mboards: '2'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8080'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
    type: complex
    vlen: nfft
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
    type: float
    vlen: nfft_spec
  states: {}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5557
    timeout: '100'
    type: float
    vlen: nfft_spec
  states: {}

connections:
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_1, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_integrate_xx_0_1_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_integrate_xx_0_0, '0', zeromq_pub_sink_0, '0']
- [blocks_integrate_xx_0_1, '0', zeromq_pub_sink_0_0, '0']
- [blocks_integrate_xx_0_1_0, '0', zeromq_pub_sink_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_2, '0']
- [blocks_stream_to_vector_0_1_0, '0', fft_vxx_0_2_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_2, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_0_2_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [uhd_usrp_source, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source, '0', blocks_stream_to_vector_0_1, '0']
- [uhd_usrp_source, '1', blocks_null_sink_0, '0']
- [uhd_usrp_source, '2', blocks_delay_0, '0']
- [uhd_usrp_source, '2', blocks_stream_to_vector_0_1_0, '0']
- [uhd_usrp_source, '3', blocks_null_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
