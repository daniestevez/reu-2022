options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: signal_detection
    output_language: python
    title: Signal detection
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: nfft
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    label: Detection threshold
    type: real
    value: '3'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import datetime


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, threshold=3.0, vlen=2**14, samp_rate=1e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Signal Detection',   # will show up in GRC
                  in_sig=[(np.float32, vlen)],
                  out_sig=[(np.float32, vlen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold
              self.signal_freq = None
              self.nfft = vlen
              self.samp_rate = samp_rate
              self.message_port_register_out(pmt.intern('detect_out'))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              #print(f'called work with in0.shape = {in0.shape} '
              #      f' at {datetime.datetime.utcnow().isoformat()}')

              median = np.median(in0, axis=1)
              detected = in0 >= self.threshold * median[:, np.newaxis]
              out0[:] = 0
              out0[detected] = in0[detected]

              argmax = np.unravel_index(np.argmax(in0), in0.shape)
              #print(f'argmax = {argmax}')
              if detected[argmax]:
                  detected_freq = np.fft.fftshift(np.fft.fftfreq(self.nfft, 1/self.samp_rate))[argmax[1]]
                  if self.signal_freq is None or self.signal_freq != detected_freq:
                      print(f'Detected signal at {detected_freq:.2f} Hz '
                            f'({datetime.datetime.utcnow().isoformat()})')
                      self.signal_freq = detected_freq
                      msg = pmt.cons(pmt.PMT_NIL, pmt.from_double(detected_freq))
                      self.message_port_pub(pmt.intern('detect_out'), msg)
              else:
                  self.signal_freq = None
              
              return len(out0)
    samp_rate: samp_rate
    threshold: threshold
    vlen: nfft
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '100'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 0.45 * samp_rate / 100, 0.1 * samp_rate / 100)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / 100
    fc: freq
    fftsize: '1024'
    type: complex
    update_time: '0.1'
    ymax: '-30'
    ymin: '-70'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '2'
    vlen: nfft
    x_axis_label: '"Frequency (Hz)"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/nfft
    y_axis_label: '"PSD (dB)"'
    ymax: '55'
    ymin: '40'
  states: {}
- name: signal_generation_0
  id: signal_generation
  parameters:
    integration_seconds: '1'
    nfft: nfft
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_nlog10_ff_0, '0', blocks_repeat_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repeat_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '0', blocks_nlog10_ff_0_0, '0']
- [epy_block_0, detect_out, blocks_message_debug_0, print]
- [epy_block_0, detect_out, blocks_msgpair_to_var_0, inpair]
- [epy_block_0, detect_out, freq_xlating_fir_filter_xxx_0, freq]
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [signal_generation_0, '0', blocks_throttle_0, '0']
- [signal_generation_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [signal_generation_0, '1', blocks_nlog10_ff_0, '0']
- [signal_generation_0, '1', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
